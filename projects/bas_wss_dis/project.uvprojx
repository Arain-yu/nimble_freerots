# Keil uVision project project.uvprojx, settings and files
target test (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.24.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10040 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD FREERTOS NRF52 NRF52832_XXAA NRF52_PAN_74 __HEAP_SIZE=8192 __STACK_SIZE=8192 NIMBLE_CFG_CONTROLLER=1
  c misc: --reduce_paths  --gnu
  c include: .\app\include;.\service;..\..\nordic\integration\nrfx;..\..\nordic\integration\nrfx\legacy;..\..\nordic\modules\nrfx;..\..\nordic\modules\nrfx\drivers\include;..\..\nordic\modules\nrfx\hal;..\..\nordic\modules\nrfx\mdk;..\..\nordic\cmsis\include;..\..\nordic\components\libraries\util;..\..\nordic\components\drivers_nrf\nrf_soc_nosd;..\..\nordic\components\libraries\log;..\..\nordic\components\libraries\log\src;..\..\nordic\components\libraries\experimental_section_vars;..\..\nordic\components\libraries\atomic;..\..\nordic\components\libraries\memobj;..\..\nordic\components\toolchain\cmsis\include;..\..\freertos\source\include;..\..\freertos\portable\ARM\nrf52;..\..\freertos\portable\CMSIS\nrf52;..\..\freertos\config;..\..\nimble;..\..\nimble\nimble\include;..\..\nimble\nimble\host\include;..\..\nimble\nimble\host\src;..\..\nimble\nimble\host\store\ram\include;..\..\nimble\nimble\host\util\include;..\..\nimble\porting\nimble\include;..\..\nimble\porting\npl\freertos\include;..\..\nimble\ext\tinycrypt\include;..\..\nimble\nimble\transport\ram\include;..\..\nimble\nimble\controller\include;..\..\nimble\nimble\drivers\nrf52\include;..\..\nimble\nimble\host\services\gap\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress 6330
  group freertos
    ../../freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../freertos/source/portable/MemMang/: heap_4.c
    ../../freertos/portable/ARM/nrf52/: port.c
    ../../freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group nordic
    ./app/: arm_startup_nrf52.s system_nrf52.c
    ../../nordic/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_uart.c
    ../../nordic/components/libraries/util/: app_util_platform.c
    ../../nordic/modules/nrfx/soc/: nrfx_atomic.c
    ../../nordic/integration/nrfx/legacy/: nrf_drv_clock.c
  group app
    ./app/: main.c board.c printf.c
    ./service/: gap_svr.c dis_svr.c wss_svr.c bas_svr.c
  group nimble/host
    ../../nimble/nimble/host/src/: ble_att.c ble_att_clt.c ble_att_cmd.c ble_att_svr.c ble_eddystone.c ble_gap.c ble_gattc.c ble_gatts.c ble_gatts_lcl.c ble_hs.c ble_hs_adv.c ble_hs_atomic.c ble_hs_cfg.c ble_hs_conn.c ble_hs_dbg.c ble_hs_flow.c ble_hs_hci.c ble_hs_hci_cmd.c ble_hs_hci_evt.c ble_hs_hci_util.c ble_hs_id.c ble_hs_log.c ble_hs_mbuf.c ble_hs_misc.c ble_hs_mqueue.c ble_hs_pvcy.c ble_hs_shutdown.c ble_hs_startup.c ble_hs_stop.c ble_ibeacon.c ble_l2cap.c ble_l2cap_coc.c ble_l2cap_sig.c ble_l2cap_sig_cmd.c ble_monitor.c ble_sm.c ble_sm_alg.c ble_sm_cmd.c ble_sm_lgcy.c ble_sm_sc.c ble_store.c ble_store_util.c ble_uuid.c
    ../../nimble/nimble/host/store/ram/src/: ble_store_ram.c
    ../../nimble/nimble/host/util/src/: addr.c
  group nimble/controller
    ../../nimble/nimble/controller/src/: ble_ll.c ble_ll_adv.c ble_ll_conn.c ble_ll_conn_hci.c ble_ll_ctrl.c ble_ll_dtm.c ble_ll_hci.c ble_ll_hci_ev.c ble_ll_rand.c ble_ll_resolv.c ble_ll_scan.c ble_ll_sched.c ble_ll_supp_cmd.c ble_ll_trace.c ble_ll_utils.c ble_ll_whitelist.c ble_ll_xcvr.c
    ../../nimble/nimble/drivers/nrf52/src/: ble_hw.c ble_phy.c
  group nimble/porting
    ../../nimble/porting/nimble/src/: endian.c hal_timer.c mem.c nimble_port.c os_cputime.c os_cputime_pwr2.c os_mbuf.c os_mempool.c os_msys_init.c
    ../../nimble/porting/npl/freertos/src/: nimble_port_freertos.c npl_os_freertos.c nrf5x_isr.c
  group nimble/other
    ../../nimble/nimble/src/: ble_util.c
    ../../nimble/nimble/transport/ram/src/: ble_hci_ram.c
    ../../nimble/ext/tinycrypt/src/: aes_decrypt.c aes_encrypt.c cmac_mode.c ecc.c ecc_dh.c utils.c
